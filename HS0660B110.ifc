Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2018-02-27T15:08:01
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160217_0900(x64) - Exporter 17.0.411.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Feb 27 15:08:01 2018 * Host: DESKTOP-AKA7PPN * Database: C:\Users\DEANJO~1\AppData\Local\Temp\{BB1EB6B9-B6A3-4313-8588-C1F6E3CA417B}\ifc * Database version: 5507 * Database creation date: Tue Feb 27 15:07:59 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Feb 27 15:08:00 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Feb 27 15:08:00 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: Standard, Family1:Standard:200127
In: Level 1
Type - Material: Stainless - Brushed
Type - Identity Data - Description: Bali - HTM64 Slop hopper; Manufacturer: Plandstainless.co.uk; Model: HS0660B110; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Type Name: Standard; URL: www.plandstainless.co.uk
Type - Model Properties - Authority: Dean Johnson; Catalog web link: www.plandstainless.co.uk; Category: Healthcare; COBie AssetType: Fixed; COBie BarCode: 5060021234513; COBie CreatedBy: Robin Hardcastle; COBie CreatedOn: 43158; COBie Description: HTM64 Slop Hopper; COBie DocumentationLiterature: www.plandstainless.co.uk; COBie DurationUnit: Years; COBie ExpectedLife: 30; COBie Features: Single Hopper - With Grid; COBie Finish: Satin/polished; COBie Grade: 304 1.4301; COBie Manufacturer: Plandstainless Ltd; COBie Material: Stainless Steel; COBie Model: Bali; COBie ModelNumber: HS0660B110; COBie Size: 600 x 600mm; COBie WarrantyDescription: Manufacturer's Warranty; COBie WarrantyDurationUnit: Years; COBie WarrantyDurrationParts: 2; COBie WarrantyGuarantorParts: YES; Company: Plandstainless Ltd; Date Created: 16/07/2002 21:06:16; Design Status: 3; Manager: Dean Johnson; Part Number: HS0660B110; Title: Bali - HTM64 Slop hopper
Type - Other - Category: Specialty Equipment; Family Name: Family1
Pset_BuildingElementProxyCommon - Reference: Standard
Pset_ManufacturerTypeInformation - Manufacturer: Plandstainless.co.uk
Constraints - Offset: 0 mm
Dimensions - Area: 0.808377 m2; Volume: 0.00204712 m3
Other - Family: Family1: Standard; Family and Type: Family1: Standard; Type: Family1: Standard; Type Id: Family1: Standard
Phasing - Phase Created: New Construction
